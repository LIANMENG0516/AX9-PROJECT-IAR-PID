# IAR project AX9.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405ZG ST STM32F405ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\DEVICE; ..\BSP; ..\CMSIS; ..\FWLIB\inc; ..\APP; $PROJ_DIR$; ..\USB\USB_APP; ..\USB\STM32_USB_OTG_Driver\inc; ..\USB\STM32_USB_Device_Library\Core\inc; ..\USB\STM32_USB_Device_Library\Class\cdc\inc; ..\UCOSIII\uCOS-CPU; ..\UCOSIII\uCOS-LIB; ..\UCOSIII\uCOS-BSP; ..\UCOSIII\uCOS-CONFIG; ..\UCOSIII\uCOS-III; ..\UCOSIII\uCOS-III\Source; ..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\UCOSIII\uCOS-CPU\ARM-Cortex-M4\IAR; ..\UCOSIII\uCOS-LIB\Ports\ARM-Cortex-M4\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AX9_APP.hex
  ILINK.IlinkOutputFile: AX9.out
  ILINK.IlinkIcfFile: C:\Users\LIANMENG\Desktop\AX9-PROJECT-IAR-PID\AX9_V1.00\source\application\USER\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: app.c app_adc.c app_adjvol.c app_com.c app_comdebug.c app_fan.c app_led.c app_pwrmanager.c app_sysonoff.c app_temperature.c app_timer.c app_usb.c
  group BSP
    ../BSP/: adc.c board.c dac.c dma.c gpio.c iic.c nvic.c spi.c systick.c timer.c usart.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group DEVICE
    ../DEVICE/: adjustvoltage.c adt7302.c bat1.c bat2.c command_process.c ds2431.c emc2305.c power.c system.c tlv5626cd.c tmp468.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UCOSIII/uCOS-BSP
    ../UCOSIII/uCOS-BSP/: bsp.c
  group UCOSIII/uCOS-CONFIG
    ../UCOSIII/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII/uCOS-CPU
    ../UCOSIII/uCOS-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../UCOSIII/uCOS-CPU/: cpu_core.c
  group UCOSIII/uCOS-III/Port
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII/uCOS-III/Source
    ../UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOSIII/uCOSIII-LIB
    ../UCOSIII/uCOS-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uCOS-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group USB/USB-APP
    ../USB/USB_APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB/USB-DEVICE
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/USB-OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USER
    ./: main.c stm32f4xx_it.c
